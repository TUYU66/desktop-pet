# Keil uVision project PetBootloader.uvprojx, settings and files
target PetBootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: PetBootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F103xE
  c misc: --no-multibyte-chars
  c include: ../../CMSIS;../../CMSIS/core;../../OTA/common;../../BSP/ChassisLink
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Bootloader
    ../../MDK-ARM/: startup_stm32f103xe.s
    ../: boot_jump.s boot_main.c boot_flash.c
    ../../OTA/common/: ota_image.c ota_boot_record.c ota_update.c ota_protocol.c
