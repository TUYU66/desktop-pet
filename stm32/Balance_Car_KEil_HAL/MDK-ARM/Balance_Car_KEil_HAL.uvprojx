# Keil uVision project Balance_Car_KEil_HAL.uvprojx, settings and files
target Balance_Car_KEil_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Balance_Car_KEil_HAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xE,PET_OTA_APPLICATION
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../STM32F1xx_HAL_Driver/Inc;../STM32F1xx_HAL_Driver/Inc/Legacy;../CMSIS;../CMSIS/core;../BSP;../BSP/Battery;../BSP/Beep;../BSP/Bluetooth;../BSP/delay;../BSP/Enconder;../BSP/IIC_Software;../BSP/INT_Sever;../BSP/Key;../BSP/LED;../BSP/Motor;../BSP/MPU6050;../BSP/MPU6050/DMP;../BSP/OLED;../BSP/Timer;../BSP/Usart1;../APP;../APP/filter;../APP/KF;../APP/PID;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ../CMSIS/core
  memory RVCT4: ROM 0x8008000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../BSP/: myenum.h AllHeader.h
    ../Core/Src/: main.c gpio.c freertos.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usart.c stm32f1xx_ll_gpio.c stm32f1xx_hal_uart.c stm32f1xx_ll_dma.c stm32f1xx_hal_usart.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/ChassisLink/: chassis_link.c
    ../BSP/Battery/: bsp_battery.c
    ../BSP/Beep/: bsp_beep.c
    ../BSP/Bluetooth/: bsp_bluetooth.c
    ../BSP/delay/: delay.c
    ../BSP/Enconder/: encoder.c
    ../BSP/IIC_Software/: IOI2C.c
    ../BSP/INT_Sever/: intsever.c
    ../BSP/Key/: bsp_key.c
    ../BSP/LED/: bsp_LED.c
    ../BSP/Motor/: motor.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/OLED/: oled_fonts.c bsp_oled_i2c.c bsp_oled.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/Usart1/: bsp_usart.c
  group APP
    ../BSP/Bluetooth/: app_bluetooth.c
    ../Core/Src/: app_runtime.c runtime_diagnostics.c
    ../APP/: app.c app_control.c app_motor.c
  group DMP
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group algorithm
    ../APP/filter/: filter.c
    ../APP/KF/: KF.c
    ../APP/PID/: pid_control.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group OTA_Application
    ../OTA/application/: ota_entry.c ota_application_system.c
